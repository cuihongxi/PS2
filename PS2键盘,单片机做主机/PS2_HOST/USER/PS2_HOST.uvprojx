# Keil uVision project PS2_HOST.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PS2_HOST +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\MYFUN\IT;..\MYFUN\MYGPIO;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MYFUN\PS2;..\USER;..\MYFUN\CUIGUI\BMP;..\MYFUN\CUIGUI\COLOR;..\MYFUN\CUIGUI\CONFIG;..\MYFUN\CUIGUI\EDIT;..\MYFUN\CUIGUI\FONT;..\MYFUN\CUIGUI\LCDDRIVER;..\MYFUN\CUIGUI\MALLCO;..\MYFUN\CUIGUI\UDATA;..\MYFUN\CUIGUI\UHEAD;..\MYFUN\LCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CODE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYS
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group MYFUN
    ../MYFUN/MYGPIO/: MYGPIO.C
    ../MYFUN/IT/: IT.C
  group PS2_KEYBOARD
    ../MYFUN/PS2/: key_map.c PS2_KEYBOARD.C key_app.c
